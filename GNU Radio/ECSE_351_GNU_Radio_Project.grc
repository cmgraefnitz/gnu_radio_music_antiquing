options:
  parameters:
    author: cmgra
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: wav_len
  id: variable
  parameters:
    value: '51800000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2'
    type: float
    vlen: wav_len
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    alias: song_source
    file: C:\Personal\Users\cmgra\Desktop\ECSE 351\GNU Radio Project\351 music antiquing\Tomorrow_Is_Today_(original).wav
    repeat: 'False'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matplotlib.pyplot as plt
      from scipy.io import wavfile
      import scipy.signal as signal
      from scipy.signal import butter, lfilter, freqz
      from IPython.display import Audio
      from gnuradio import gr

      import pmt

      textboxValue = ""

      Morse = {
        # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
          "A": "1,0,1,1,1",
          "B": "1,1,1,0,1,0,1,0,1",
          "C": "1,1,1,0,1,0,1,1,1,0,1",
          "D": "1,1,1,0,1,0,1",
          "E": "1",
          "F": "1,0,1,0,1,1,1,0,1",
          "G": "1,1,1,0,1,1,1,0,1",
          "H": "1,0,1,0,1,0,1",
          "I": "1,0,1",
          "J": "1,0,1,1,1,0,1,1,1,0,1,1,1",
          "K": "1,1,1,0,1,0,1,1,1",
          "L": "1,0,1,1,1,0,1,0,1",
          "M": "1,1,1,0,1,1,1",
          "N": "1,1,1,0,1",
          "O": "1,1,1,0,1,1,1,0,1,1,1",
          "P": "1,0,1,1,1,0,1,1,1,0,1",
          "Q": "1,1,1,0,1,1,1,0,1,0,1,1,1",
          "R": "1,0,1,1,1,0,1",
          "S": "1,0,1,0,1",
          "T": "1,1,1",
          "U": "1,0,1,0,1,1,1",
          "V": "1,0,1,0,1,0,1,1,1",
          "W": "1,0,1,1,1,0,1,1,1",
          "X": "1,1,1,0,1,0,1,0,1,1,1",
          "Y": "1,1,1,0,1,0,1,1,1,0,1,1,1",
          "Z": "1,1,1,0,1,1,1,0,1,0,1",
          " ": "0",            # space
          "1": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "2": "1,0,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "3": "1,0,1,0,1,0,1,1,1,0,1,1,1",
          "4": "1,0,1,0,1,0,1,0,1,1,1",
          "5": "1,0,1,0,1,0,1,0,1",
          "6": "1,1,1,0,1,0,1,0,1,0,1",
          "7": "1,1,1,0,1,1,1,0,1,0,1,0,1",
          "8": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1",
          "9": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",
          "0": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          ".": "1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1",          # period
          ",": "1,1,1,0,1,1,1,0,1,0,1,0,1,1,1,0,1,1,1",      # comma
          ":": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1",          # colon
          "?": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1",              # question
          "'": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",      # apostrophe
          "-": "1,1,1,0,1,0,1,0,1,0,1,0,1,1,1",              # dash or minus
          "/": "1,1,1,0,1,0,1,0,1,1,1,0,1",                  # slash
          "(": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1",              # left parenthesis
          ")": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",      # right parenthesis
          "\"": "1,0,1,1,1,0,1,0,1,0,1,1,1,0,1",             # quote
          "=": "1,1,1,0,1,0,1,0,1,0,1,1,1",                  # equals
          "+": "1,0,1,1,1,0,1,0,1,1,1,0,1",                  # plus
          "@": "1,0,1,1,1,0,1,1,1,0,1,0,1,1,1,0,1",          # at sign (@)
        # these punctuation marks are not included in the ITU recommendation,
        # but are found in https://en.wikipedia.org/wiki/Morse_code
          "!": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,1",      # exclamation point
          "&": "1,0,1,1,1,0,1,0,1,0,1",                      # ampersand (also prosign for 'WAIT')
          ";": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1",          # semicolon
          "_": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",          # underscore
          "$": "1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,1,1"           # dollar sign
            }

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Morse code vector source",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue
              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global Morse
              global textboxValue
              bit_stream = ""
              if (len (textboxValue) > 0):
                  for in0 in textboxValue:
                      # get next char
                      inChar = str (in0)
                      # convert to upper case
                      ch = inChar.upper()
                      # test for character in table
                      if (not(ch in Morse)):
                      # print ("bad char", ch)
                          ch = "?"        # replace bad character with a '?'
                      # build vector
                      _dots = str (Morse.get(ch))
                      # print (ch, _dots)
                      bit_stream += (_dots + ",0,0,0,")    # letter space

                  bit_stream += "0,0,0,0"    # finish with word space
                  # print (bit_stream)

                  # get length of string
                  _len = len(bit_stream)
                  # num of elements = (length+1) / 2
                  _num_elem = int((_len+1) / 2)

                  # convert and store elements in output array
                  for x in range (_len):
                      y = int(x / 2)
                      if (bit_stream[x] == '1'):
                          output_items[0][y] = 1
                      elif (bit_stream[x] == '0'):
                          output_items[0][y] = 0
                      else:
                          continue    # skip commas

                  # clear input line
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              else:
                  _num_elem = 0

              return (_num_elem)
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_stream_to_vector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
