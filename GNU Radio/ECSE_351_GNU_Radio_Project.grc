options:
  parameters:
    author: cmgra
    generate_options: qt_gui
    id: options
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AM_f1
  id: variable
  parameters:
    value: '200'
  states: {}
- name: AM_f2
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: AM_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: band_pass
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: FM_f1
  id: variable
  parameters:
    value: '30'
  states: {}
- name: FM_f2
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: FM_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '30'
    samp_rate: samp_rate
    type: band_pass
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: allpass_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: band_pass
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: delay
  id: variable
  parameters:
    value: '2'
  states: {}
- name: gramophone_f1
  id: variable
  parameters:
    value: '160'
  states: {}
- name: gramophone_f2
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: gramophone_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '2000'
    low_cutoff_freq: '160'
    samp_rate: samp_rate
    type: band_pass
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: noisy
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Noisy
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: nyq_freq
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: select
  id: variable_qtgui_chooser
  parameters:
    label: Select Filter
    label0: Original
    label1: Gramophone
    label2: AM
    label3: FM
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: update
  id: variable
  parameters:
    value: '.05'
  states: {}
- name: wav_len
  id: variable
  parameters:
    value: '51800000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 1.3/120
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.025'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1.3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_max_xx_1
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.1'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {state: disabled}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noisy
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    alias: song_source
    file: C:\Users\cmgra\Desktop\ECSE 351\gnu_radio_music_antiquing\351 music antiquing\Tomorrow_Is_Today_(original).wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Add AWGN with SNR and Noise Floor
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Adds AWGN with configurable SNR and minimum noise floor"""
          
          def __init__(self, snr=10.0, noise_offset=-40.0):
              gr.sync_block.__init__(
                  self,
                  name='Add AWGN',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.snr = snr
              self.noise_offset = noise_offset
              self.rng = np.random.default_rng()
              
              # Convert noise floor from dB to power (10^(dB/10))
              self.offset_power = 10**(self.noise_offset/10)

          def work(self, input_items, output_items):
              x = input_items[0]    # Input signal
              y = output_items[0]   # Output buffer
              
              # Calculate signal power (mean-square)
              signal_power = np.mean(np.abs(x**2))
              
              # Calculate required noise power based on snr
              noise_power = signal_power / 10**(self.snr/10)
              
              # Apply noise floor: use whichever is LARGER (max())
              # noise_power = max(noise_power, self.offset_power)
              
              # Generate Gaussian noise with calculated power
              # noise = self.rng.normal(0, np.sqrt(noise_power), len(x))
              
              # Generate noise
              noise = self.rng.normal(0, np.sqrt(noise_power), x.shape)
              
              # Add noise to signal
              y[:] = x + noise
              
              return len(y)
    noise_offset: '-40'
    snr: '10'
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: allpass_taps
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: gramophone_taps
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: AM_taps
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: FM_taps
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: update
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    update_time: update
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    update_time: update
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: update
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_complex_to_real_0, '0']
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_noise_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_abs_xx_0, '0', blocks_max_xx_0, '0']
- [blocks_abs_xx_1, '0', blocks_max_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_selector_1, '1']
- [blocks_complex_to_real_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_selector_0_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_selector_0_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', audio_sink_1_0, '0']
- [blocks_selector_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_selector_0_0, '1']
- [interp_fir_filter_xxx_0_0_0, '0', blocks_selector_0_0, '2']
- [interp_fir_filter_xxx_0_0_0_0, '0', blocks_selector_0_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
