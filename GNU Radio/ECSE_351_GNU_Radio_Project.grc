options:
  parameters:
    author: cmgra
    generate_options: qt_gui
    id: options
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: choose_effect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Effect
    label0: None
    label1: Wow
    label2: Flutter
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: raw
    value: '0'
  states: {}
- name: choose_filter
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Filter
    label0: Original
    label1: Gramophone
    label2: AM
    label3: FM
    label4: Telephone
    num_opts: '5'
    option0: '[20,20000]'
    option1: '[160,2000]'
    option2: '[200,5000]'
    option3: '[30,15000]'
    option4: '[30,3000]'
    type: raw
    value: '[20,20000]'
  states: {}
- name: filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: choose_filter[1]
    low_cutoff_freq: choose_filter[0]
    samp_rate: samp_rate
    type: band_pass
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: flutter_depth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '''Flutter'' Depth'
    start: '0'
    step: '.0001'
    stop: '.02'
    value: '.008'
  states: {}
- name: flutter_fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Flutter Frequency
    start: '6'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: noisy
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,0,1,1
    label: Noisy
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: update
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: wow_depth
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '''Wow'' Depth'
    start: '0'
    step: '.0001'
    stop: '.02'
    value: 1/120
  states: {}
- name: wow_fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Wow Frequency
    start: '0'
    step: '.1'
    stop: '6'
    value: '1.3'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.025'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: wow_depth
    freq: wow_fc
    offset: '1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: flutter_depth
    freq: flutter_fc
    offset: '1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noisy
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose_effect
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    alias: song_source
    file: C:\Users\cmgra\Desktop\ECSE 351\gnu_radio_music_antiquing\GNU Radio\Tomorrow_Is_Today_Billy_Joel.wav
    repeat: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '4'
    taps: '[1,0,0,0]'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: filter_taps
    type: fff
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: float
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '256'
    gui_hint: 3,0,1,2
    norm_window: 'True'
    type: float
    update_time: update
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 3,2,1,2
    legend: 'False'
    size: '256'
    srate: samp_rate
    type: float
    update_time: update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: update
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_audio
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: wow_audio
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: flutter_audio
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: wow_flutter_audio
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_audio
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_audio
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: wow_audio
  states: {state: disabled}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: wow_audio
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: flutter_audio
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: wow_flutter_audio
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: filtered_audio
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0, '0', mmse_resampler_xx_0, '1']
- [analog_sig_source_x_0_0, '0', mmse_resampler_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', mmse_resampler_xx_0_0_0, '1']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', audio_sink_1_0, '0']
- [blocks_selector_0, '0', fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_1, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_1, '0']
- [mmse_resampler_xx_0_0, '0', virtual_sink_1_0, '0']
- [mmse_resampler_xx_0_0_0, '0', virtual_sink_1_0_0, '0']
- [virtual_source_0, '0', mmse_resampler_xx_0, '0']
- [virtual_source_0_0, '0', mmse_resampler_xx_0_0, '0']
- [virtual_source_0_0_0, '0', mmse_resampler_xx_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_selector_0, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_selector_0, '2']
- [virtual_source_0_1, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
